FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0099-added-patch-for-power-managment-and-initial-GPIO-set.patch"

